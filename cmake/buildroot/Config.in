## cmake/buildroot/package/cmake_test/Config.in
```kconfig
config BR2_PACKAGE_CMAKE_TEST
	bool "cmake_test"
	help
	  Cmake test for buildroot
```
